# Keil uVision project stm32f103RB.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\delay;..\Booter;..\Drivers\CORE;..\Drivers\HALLIB\STM32F1xx_HAL_Driver\Inc;..\PikaScript\pikascript-lib/PikaStdDevice;..\PikaScript\pikascript-lib/STM32F1;..\PikaScript\pikascript-lib/PikaStdLib;..\PikaScript\pikascript-api;..\PikaScript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Booter
    ../Booter/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
    ../Drivers/CORE/: startup_stm32f103xb.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../Drivers/HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group README
    ../: README.TXT
  group pikascript-core
    ../PikaScript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-lib
    ../PikaScript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_Time.c PikaStdDevice_UART.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c
    ../PikaScript/pikascript-lib/STM32F1/: STM32F1_PWM.c STM32F1_ADC.c STM32F1_IIC.c STM32F1_Time.c STM32F1_common.c STM32F1_GPIO.c STM32F1_UART.c
    ../PikaScript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
  group pikascript-api
    ../PikaScript/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
  group Python
    ../PikaScript/: requestment.txt main.py PikaObj.pyi PikaStdDevice.pyi PikaStdLib.pyi STM32F1.pyi
software components: CMSIS:CORE 5.4.0

# Keil uVision project stm32g070.uvprojx, settings and files
target stm32g070 (6180000::V6.18::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g070 +hex
  BeforeMake: ..\pikascript\pikaBeforBuild-keil.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER, USE_HAL_DRIVER,STM32G070xx
  c include: ..\Booter;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include;..\pikascript\pikascript-lib/PikaStdDevice;..\pikascript\pikascript-lib/time;..\pikascript\pikascript-lib/STM32G0;..\pikascript\pikascript-lib/PikaPiZero;..\pikascript\pikascript-lib/PikaStdLib;..\pikascript\pikascript-api;..\pikascript\pikascript-core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Booter
    ../Booter/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c startup_stm32g070xx.s pika_config.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_gpio.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_ll_adc.c stm32g0xx_ll_tim.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c
  group pikascript-core
    ../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c PikaCompiler.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_IIC.c PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_common.c PikaStdDevice_GPIO.c PikaStdDevice_CAN.c PikaStdDevice_UART.c PikaStdDevice_PWM.c pika_hal.c PikaStdDevice_SPI.c pika_hal_SOFT_SPI.c PikaStdDevice_DAC.c
    ../pikascript/pikascript-lib/time/: _time.c
    ../pikascript/pikascript-lib/STM32G0/: STM32G0_common.c pika_hal_STM32G0_GPIO.c pika_hal_STM32G0_PWM.c pika_hal_STM32G0_ADC.c pika_hal_STM32G0_UART.c pika_hal_STM32G0_SPI.c
    ../pikascript/pikascript-lib/PikaPiZero/: PikaPiZero_RGB.c PikaPiZero_KEY.c arm2d_config.c PikaPiZero_LCD.c LCD_Driver.c RGB_ASM.lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_RangeObj.c PikaStdData_Dict.c PikaStdTask_Task.c PikaStdLib_StringObj.c PikaStdData_Tuple.c PikaStdLib_MemChecker.c PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_String.c PikaStdData_Utils.c PikaStdData_List.c PikaStdLib_SysObj.c PikaStdData_FILEIO.c
  group Python
    ../pikascript/: requestment.txt main.py PikaObj.pyi PikaStdLib.pyi STM32G0.pyi PikaStdDevice.pyi machine.py
  group CMSIS/DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM0l_math.lib
  group pikascript-api
    ../pikascript/pikascript-api/: pikaScript.c __pikaBinding.c __asset_pikaModules_py_a.c
software components: CMSIS:CORE 5.5.0
